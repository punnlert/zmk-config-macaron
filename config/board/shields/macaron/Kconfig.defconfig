## config/boards/shields/macaron/Kconfig.defconfig
```kconfig
if SHIELD_MACARON

config ZMK_KEYBOARD_NAME
    default "macaron"

endif

CONFIG_EC11=y
CONFIG_EC11_TRIGGER_GLOBAL_THREAD=y
```
